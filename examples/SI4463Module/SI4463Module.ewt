<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Cpu</name>
    <group>
      <name>STM8A-S</name>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_adc1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_adc2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_awu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_rst.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_tim1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_tim3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_tim5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_tim6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_uart1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_uart2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_uart3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cpu\STM8A-S\src\stm8s_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>OS-Core</name>
    <group>
      <name>cfs</name>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\cfs\cfs-coffee.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\cfs\cfs-eeprom.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\cfs\cfs-posix-dir.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\cfs\cfs-posix.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\cfs\cfs-ram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\cfs\cfs-xmem.c</name>
      </file>
    </group>
    <group>
      <name>ctk</name>
    </group>
    <group>
      <name>dev</name>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\aes-128.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\crc16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\lib\ctk-filedialog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\lib\ctk-textentry-checkbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\lib\ctk-textentry-cmdline.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\lib\ctk-textentry-multiline.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\gcr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\ifft.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\me.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\me_tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\mmem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\petsciiconv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\print-stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\sensors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\settings.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\trickle-timer.c</name>
      </file>
    </group>
    <group>
      <name>loader</name>
    </group>
    <group>
      <name>net</name>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\mt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\OS-Core\sys\profile-aggregates.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Radio</name>
      <file>
        <name>$PROJ_DIR$\..\..\platform\SI4463Module\Radio\radio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\SI4463Module\Radio\radio_comm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\SI4463Module\Radio\radio_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\SI4463Module\Radio\si446x_api_lib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\SI4463Module\Radio\si446x_nirq.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\platform\SI4463Module\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\platform\SI4463Module\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\platform\SI4463Module\rtimer-arch.c</name>
    </file>
  </group>
  <group>
    <name>Project</name>
    <file>
      <name>$PROJ_DIR$\global.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\packetsbuf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\uart.c</name>
    </file>
  </group>
</project>


