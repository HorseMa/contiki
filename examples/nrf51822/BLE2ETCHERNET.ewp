# IAR project BLE2ETCHERNET.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422-QFAA NordicSemi nRF51422-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: AUTOSTART_ENABLE=1; NRF51
  ICCARM.CCIncludePath2: ; ../../core\; ../../examples/nrf51822; ../../examples/nrf51822/net; ../../examples/nrf51822/spi_master; ../../examples/nrf51822/w5500; ../../cpu/nrf51822\; ../../cpu/nrf51822/nrf51822\; ../../cpu/nrf51822/nrf51822/timer\; ../../cpu/nrf51822/nrf51822/simple_timer\; ../../core/sys\; ../../core/lib\; ../../platform/nrf51822\; ../../platform/nrf51822\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE2ETCHERNET.srec
  ILINK.IlinkOutputFile: BLE2ETCHERNET.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Cpu
    ../../cpu/nrf51822/nrf51822/: app_error.c iar_startup_nrf51.s nrf_delay.c nrf_drv_common.c radio_config.c system_nrf51.c
    ../../cpu/nrf51822/nrf51822/simple_timer/: app_simple_timer.c
    ../../cpu/nrf51822/nrf51822/timer/: nrf_drv_timer.c
  group OS-Core/lib
    ../../core/lib/: aes-128.c assert.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c trickle-timer.c
  group OS-Core/sys
    ../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group Platform
    ../../platform/nrf51822/: clock.c rtimer-arch.c
  group User
    ../../cpu/nrf51822/nrf51822/: bps.c
    ./: main.c stm32f10x_it.c tasks.c
  group User/net
    net/: device.c dhcp.c dns.c sockutil.c util.c
  group User/spi_master
    spi_master/: spi_master.c
  group User/w5500
    w5500/: md5.c socket.c SPI2.c w5500.c
