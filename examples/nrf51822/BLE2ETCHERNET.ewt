<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>259</archiveVersion>
      <data>
        <version>259</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
          <enableFalsePositives>0</enableFalsePositives>
          <messagesLimitEnabled>1</messagesLimitEnabled>
          <messagesLimit>100</messagesLimit>
        </cstatargs>
        <cstat_settings>
          <cstat_version>1.3.3</cstat_version>
          <checks_tree>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
            </package>
          </checks_tree>
        </cstat_settings>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>259</archiveVersion>
      <data>
        <version>259</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>1</parallelThreads>
          <enableFalsePositives>0</enableFalsePositives>
          <messagesLimitEnabled>1</messagesLimitEnabled>
          <messagesLimit>100</messagesLimit>
        </cstatargs>
        <cstat_settings>
          <cstat_version>1.3.3</cstat_version>
          <checks_tree>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
            </package>
            <package>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
              <group>
                <check></check>
              </group>
            </package>
          </checks_tree>
        </cstat_settings>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Cpu</name>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\app_error.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\uart\app_fifo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\uart\app_gpiote.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\simple_timer\app_simple_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\uart\app_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\uart\app_uart_fifo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\app_util_platform.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\ble_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\iar_startup_nrf51.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\nrf_delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\nrf_drv_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\uart\nrf_drv_gpiote.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\timer\nrf_drv_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\nrf_drv_wdt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\nrf_soc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\radio_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\simple_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\system_nrf51.c</name>
    </file>
  </group>
  <group>
    <name>OS-Core</name>
    <group>
      <name>cfs</name>
    </group>
    <group>
      <name>ctk</name>
    </group>
    <group>
      <name>dev</name>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\aes-128.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\crc16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\gcr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\ifft.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\me.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\me_tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\mmem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\petsciiconv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\print-stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\sensors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\settings.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\lib\trickle-timer.c</name>
      </file>
    </group>
    <group>
      <name>loader</name>
    </group>
    <group>
      <name>net</name>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\mt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core\sys\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <file>
      <name>$PROJ_DIR$\..\..\platform\nrf51822\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\platform\nrf51822\rtimer-arch.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>net</name>
      <file>
        <name>$PROJ_DIR$\net\device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\net\dhcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\net\dns.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\net\sockutil.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\net\util.c</name>
      </file>
    </group>
    <group>
      <name>radio</name>
      <file>
        <name>$PROJ_DIR$\..\..\platform\nrf51822\Radio\radio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\nrf51822\Radio\radio_comm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\nrf51822\Radio\radio_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\nrf51822\Radio\si446x_api_lib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\nrf51822\Radio\si446x_nirq.c</name>
      </file>
    </group>
    <group>
      <name>spi_master</name>
      <file>
        <name>$PROJ_DIR$\spi_master\spi_master.c</name>
      </file>
    </group>
    <group>
      <name>w5500</name>
      <file>
        <name>$PROJ_DIR$\w5500\md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\w5500\socket.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\w5500\SPI2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\w5500\w5500.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\ad_hoc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\cpu\nrf51822\nrf51822\bps.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\dev_cfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\dev_list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\mai_no_os.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tags_manage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tasks.c</name>
    </file>
  </group>
</project>


