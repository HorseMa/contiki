# IAR project systemrun.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ../../core\; ../../examples/nrf51822\; ../../examples/nrf51822/net\; ../../examples/nrf51822/spi_master\; ../../examples/nrf51822/w5500\; ../../cpu/nrf51822\; ../../cpu/nrf51822/nrf51822\; ../../cpu/nrf51822/nrf51822/uart\; ../../cpu/nrf51822/nrf51822/timer\; ../../cpu/nrf51822/nrf51822/simple_timer\; ../../core/sys\; ../../core/lib\; ../../platform/nrf51822\; ../../platform/nrf51822/Radio\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: systemrun.srec
  ILINK.IlinkOutputFile: systemrun.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: systemrun.c
