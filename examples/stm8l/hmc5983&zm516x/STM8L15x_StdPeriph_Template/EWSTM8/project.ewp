# IAR project project.ewp, settings and files
configuration STM8L15X_MD(STM8L15xx4_6) (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x000
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L15X_MD; AUTOSTART_ENABLE
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc; ..\..\..\Core; ..\..\..\Core\sys; ..\..\..\Core\lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8L15X_HD(STM8L15xx8_16xx8) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152M8 STM8L152M8
  General.GenCodeModel: 2
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L15X_HD
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1528_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
configuration STM8L15X_LD(STM8L15xx2_3) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C3 STM8L151C3
  General.GenCodeModel: 0
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L15X_LD
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
configuration STM8L05X_LD_VL(STM8L05xx3) (STM8, debug)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenStackSize: 0x150
  General.GenHeapSize: 0x0
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_LD_VL; AUTOSTART_ENABLE; xUSE_FULL_ASSERT; BUTTON_SENSOR_CONF_ON=TRUE
  ICCSTM8.CCIncludePath2: ..; ..\..\..\..\..\platform\stm8l\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc; ..\..\..\..\..\Core; ..\..\..\..\..\Core\sys; ..\..\..\..\..\Core\lib; ..\..\..\..\..\Core\lib\strncasecmp; ..\STM8L15x_StdPeriph_Template
configuration STM8L05X_MD_VL(STM8L05xx6) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: as above
configuration STM8L05X_HD_VL(STM8L05xx8) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 2
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: as above
  group Core/Lib
    ../../../../../core/lib/: aes-128.c assert.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c trickle-timer.c
  group Core/Sys
    ../../../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group STM8L15x_StdPeriph_Driver
    ../../../../../platform/stm8l/STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../: button-sensor.c clock.c hmc5983.c main.c rtimer-arch.c stm8l15x_it.c tasks.c
